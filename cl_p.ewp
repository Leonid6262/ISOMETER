# IAR project cl_p.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4078 NXP LPC4078
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186, Pe161, Pe191, Pe009,Pa093,Pe068,Pe550
  ICCARM.CCIncludePath2: $PROJ_DIR$; LPC\; SRC\; OBJ\; SRC\INIT\; SRC\ANALOG\; SRC\TEST\; SRC\MB_SLAVE\; SRC\PULSES\; SRC\PULSES\REGULATORS\; SRC\SERIAL\; SRC\PROCESS\; SRC\DEVICE_DATA\; SRC\TERMINAL\TERMINAL_DATA\; SRC\TERMINAL\TERMINAL_CODE\; SRC\PERIPHERIALS\; SRC\ENET\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: cl_p.srec
  prebuild: version.bat
  ILINK.IlinkOutputFile: cl_p.out
  ILINK.IlinkIcfFile: lpc\MemoryMap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: cpp.out
  group (top)
    lpc/: MemoryMap.icf startup_LPC177x_8x.s
  group LPC
    lpc/: fpu_init.c system_LPC177x.c
  group SRC
    SRC/: _factory.cpp _main.cpp bool_name.hpp Config.hpp controllerDMA.cpp crc16.hpp IntPriority.hpp out_4_20mA.cpp pause_us.hpp rtc.cpp settings_eep.cpp settings_eep.hpp
  group SRC/ANALOG
    SRC/ANALOG/: adc.cpp dac.cpp
  group SRC/ENET
    SRC/ENET/: emac.cpp enet_drv.cpp net_structs.hpp udp_server.cpp udp_server.hpp
  group SRC/MB_SLAVE
    SRC/MB_SLAVE/: mb_rtu_slave.cpp mb_udp_slave.cpp mbDataProxy.hpp mbUartDriver.cpp
  group SRC/PERIPHERIALS
    SRC/PERIPHERIALS/: ControlBits.hpp emc.hpp PeripheralsInit.hpp
  group SRC/PROCESS
    SRC/PROCESS/: event_log.cpp process.cpp
  group SRC/SERIAL
    SRC/SERIAL/: set_spi.hpp set_uart.cpp
  group SRC/TERMINAL/TERMINAL_CODE
    SRC/TERMINAL/TERMINAL_CODE/: key_kodes.hpp log_display.cpp menu_navigation.cpp string_utils.cpp terminal_manager.cpp terminalUartDriver.cpp
  group SRC/TERMINAL/TERMINAL_DATA
    SRC/TERMINAL/TERMINAL_DATA/: menu_factory.hpp
